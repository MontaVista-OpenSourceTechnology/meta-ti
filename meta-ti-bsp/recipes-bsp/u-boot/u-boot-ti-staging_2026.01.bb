require u-boot-ti.inc

PR = "r0"

BRANCH = "ti-u-boot-2026.01"

SRCREV_uboot = "74701f167282c1e0639295b120b422bcdfa3f193"
